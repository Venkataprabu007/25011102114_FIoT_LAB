# Keil uVision project lab-6.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8252 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: TASK6B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lab6.c
